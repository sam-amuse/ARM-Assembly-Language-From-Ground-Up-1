# Keil uVision project FIFO_with_counter.uvprojx, settings and files
target STM32F407 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FIFO_with_counter +hex
  BeforeMake: fromelf -crs -o "C:\Users\Samir\Desktop\Arm Assembly from ground up\31_FIFO\Objects\fromelf_output" "C:\Users\Samir\Desktop\Arm Assembly from ground up\31_FIFO\Objects\fifo.o"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --trace r --list
  group Source
    ./: main.s fifo.s
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
